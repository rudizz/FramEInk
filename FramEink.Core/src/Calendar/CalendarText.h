#pragma once

#include <cstddef>
#include <cstdint>

namespace frameink {

// Calendar fields use one byte per display glyph, NOT UTF-8. ASCII and Latin-1
// retain their byte values. These extra letters/symbols occupy unused C1 slots.
// tools/build_calendar_fonts.py reads this same table to generate all four fonts.
constexpr uint32_t calendarExtraCodepoints[] = {
    0x1E9E, 0x0152, 0x0153, 0x0160, 0x0161, 0x017D, 0x017E, 0x0178, 0x20AC
};

inline uint8_t calendarGlyphForCodepoint(uint32_t codepoint)
{
    if ((codepoint >= 0x20 && codepoint <= 0x7E) || (codepoint >= 0xA1 && codepoint <= 0xFF))
        return static_cast<uint8_t>(codepoint);
    if (codepoint == 0xA0)
        return ' ';
    for (size_t i = 0; i < sizeof(calendarExtraCodepoints) / sizeof(calendarExtraCodepoints[0]); ++i)
        if (codepoint == calendarExtraCodepoints[i])
            return static_cast<uint8_t>(0x80 + i);
    return 0;
}

inline uint8_t composeCalendarAccent(uint8_t base, uint32_t mark)
{
    struct Accent { char base; uint16_t mark; uint16_t composed; };
    static constexpr Accent accents[] = {
        {'A',0x300,0xC0}, {'A',0x301,0xC1}, {'A',0x302,0xC2}, {'A',0x303,0xC3}, {'A',0x308,0xC4}, {'A',0x30A,0xC5},
        {'a',0x300,0xE0}, {'a',0x301,0xE1}, {'a',0x302,0xE2}, {'a',0x303,0xE3}, {'a',0x308,0xE4}, {'a',0x30A,0xE5},
        {'C',0x327,0xC7}, {'c',0x327,0xE7},
        {'E',0x300,0xC8}, {'E',0x301,0xC9}, {'E',0x302,0xCA}, {'E',0x308,0xCB},
        {'e',0x300,0xE8}, {'e',0x301,0xE9}, {'e',0x302,0xEA}, {'e',0x308,0xEB},
        {'I',0x300,0xCC}, {'I',0x301,0xCD}, {'I',0x302,0xCE}, {'I',0x308,0xCF},
        {'i',0x300,0xEC}, {'i',0x301,0xED}, {'i',0x302,0xEE}, {'i',0x308,0xEF},
        {'N',0x303,0xD1}, {'n',0x303,0xF1},
        {'O',0x300,0xD2}, {'O',0x301,0xD3}, {'O',0x302,0xD4}, {'O',0x303,0xD5}, {'O',0x308,0xD6},
        {'o',0x300,0xF2}, {'o',0x301,0xF3}, {'o',0x302,0xF4}, {'o',0x303,0xF5}, {'o',0x308,0xF6},
        {'U',0x300,0xD9}, {'U',0x301,0xDA}, {'U',0x302,0xDB}, {'U',0x308,0xDC},
        {'u',0x300,0xF9}, {'u',0x301,0xFA}, {'u',0x302,0xFB}, {'u',0x308,0xFC},
        {'Y',0x301,0xDD}, {'Y',0x308,0x178}, {'y',0x301,0xFD}, {'y',0x308,0xFF},
        {'S',0x30C,0x160}, {'s',0x30C,0x161}, {'Z',0x30C,0x17D}, {'z',0x30C,0x17E}
    };
    for (const auto &accent : accents)
        if (base == static_cast<uint8_t>(accent.base) && mark == accent.mark)
            return calendarGlyphForCodepoint(accent.composed);
    return 0;
}

} // namespace frameink
